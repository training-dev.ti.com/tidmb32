# Altium PCB PMP22670_PCB.PcbDoc (part 2 of 2)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 3010.03 x 2810.03 mil, 4 copper layers (Top Layer, GND Layer, Signal Layer, Bottom Layer), stack 61.2 mil thick; 62 components, 17 nets, 102 pads, 242 vias.

## Via types
v1: diameter 24, hole 10, Top Layer to Bottom Layer, tented both sides, 134 vias
v2: diameter 22, hole 10, Top Layer to Bottom Layer, tented both sides, 54 vias
v3: diameter 20, hole 10, Top Layer to Bottom Layer, tented both sides, 51 vias
v4: diameter 20, hole 10, Top Layer to Bottom Layer, tented bottom, 3 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
BOOT: C1.1 U1.6 | length 42.6
  Top Layer w10: U1.6@1602.39,1277.05 1616.47,1277.05 1628.52,1265 C1.1@1640,1265
EN: R2.1 R5.2 R11.2 U1.3 | length 167.7
  Top Layer w9: v3(1485,1280) 1487.95,1277.05 U1.3@1531.53,1277.05
  Bottom Layer w9: v3@1483,1282 v3(1485,1280) 1464,1280 R2.1@1460,1276 1460,1337 1468.31,1345.31 R5.2@1486,1345.31
FB: C15.2 R7.1 R9.1 U1.8 | length 143
  Top Layer w10: 1607.5,1329.42 1607.5,1363.6 1624.68,1380.78 R9.1@1624.68,1395 ; R9.1@1625,1395 C15.2@1660.31,1395 R7.1@1660.32,1360
GND: C3.1 C4.2 C5.1 C6.2 C7.2 C8.2 C9.2 C10.1 C11.1 C12.1 C13.1 C14.2 J3.1 J4.1 R3.1 R4.1 R5.1 R9.2 R12.2 TP5.1 TP6.1 TP7.1 TP8.1 TP12.1 TP13.1 TP14.1 U1.9
  other v1: 108,266 308,266 508,266 708,266 908,266 1108,266 1308,266 1508,266 1708,266 1908,266 2108,266 2308,266 2508,266 2708,266 408,466 608,466 808,466 1008,466 1208,466 1408,466 1608,466 1808,466 2008,466 2208,466 2408,466 108,666 308,666 508,666 708,666 908,666 1108,666 1308,666 1508,666 1708,666 1908,666 2108,666 2308,666 208,866 408,866 608,866 808,866 1008,866 1208,866 1408,866 108,1066 308,1066 508,1066 1908,1066 208,1266 408,1266 808,1266 1008,1266 1808,1266 108,1466 308,1466 708,1466 908,1466 1108,1466 1308,1466 1508,1466 1708,1466 1908,1466 2108,1466 2308,1466 2508,1466 2708,1466 208,1666 408,1666 1008,1666 1208,1666 1408,1666 1608,1666 1808,1666 2008,1666 2208,1666 2408,1666 2808,1666 108,1866 308,1866 908,1866 1108,1866 1308,1866 1508,1866 1708,1866 1908,1866 2108,1866 2308,1866 2508,1866 208,2066 408,2066 608,2066 808,2066 1008,2066 1208,2066 1408,2066 1608,2066 1808,2066 2008,2066 2208,2066 2408,2066 2608,2066 2808,2066 708,2266 908,2266 1108,2266 1308,2266 1508,2266 1708,2266 1908,2266 2108,2266 2308,2266 2508,2266 2708,2266 1208,2466 1408,2466 1608,2466 1808,2466 2008,2466 2208,2466 2408,2466 2608,2466 2808,2466 708,2666 1308,2666 1508,2666 1708,2666 1908,2666 2108,2666 2308,2666 2508,2666 2708,2666
  other v2: 792,1009 839,1009 901,1009 958.33,1009.36 1020.33,1009.36 1082.33,1009.36 1144.32,1008.73 1206.32,1008.73 1268.32,1008.73 1330.32,1008.73 1392.32,1008.73 744,1027 1413,1050 703,1059 1442,1082 667,1093 1479,1105 628.1,1132.68 584.26,1176.53 540.42,1220.37 830.26,1224.49 892.26,1224.49 954.26,1224.49 1016.26,1224.49 773.9,1250.32 496.57,1264.21 1058.66,1269.72 1118.48,1286 1180.48,1286 1242.48,1286 1304.48,1286 1366.48,1286 730.06,1294.16 453.15,1308.46 686.22,1338 446.73,1370.13 671.27,1398.17 446.73,1432.13 676.27,1459.97 446.73,1494.13 676.27,1521.97 428.96,1576.97 696.01,1576.72 428.56,1638.97 696.44,1638.72 428.56,1700.97 428.56,1762.97 428.56,1824.97 428.56,1948.97 696.44,1948.72 428.69,2010.97 696.35,2010.72 466.99,2059.73 658.31,2059.69
  other v3: 1663,990 1701,990 1632,1007 1732,1012 1625,1050 1737,1055 1530,1065 1737,1088 1625,1090 1530,1105 1737,1120 1625,1125 1737,1155 1632,1165 1735,1195 1776.81,1220.37 1724,1225 1725,1265 1725,1295 1725,1322 1535,1360 1560,1360 1585,1360 1535,1385 1560,1385
MODE/SYNC: R8.2 R10.2 R12.1 U1.1 | length 97.9
  Top Layer w12: R10.2@1494.68,1361.75 R12.1@1494.68,1330 1525.84,1330 ; R10.2@1494.69,1365 R8.2@1494.69,1400
NetC2_2: C2.2 R3.2 R4.2
NetC9_1: C9.1 R1.1
NetC15_1: C15.1 R6.1 R7.2 | length 80.6
  Top Layer w10: R7.2@1699.69,1360 C15.1@1699.68,1395 R6.1@1745.32,1395
NetR11_1: R11.1 TP11.1 | length 1806.9
  Signal Layer w9: v3(1394,1310) 1355,1349 1355,1511.14 1582.86,1739 2414,1739 2475,1800 2475,1955 2520,2000 v4(2625,2000)
  Bottom Layer w9: v3(1394,1310) R11.1@1420.32,1310
PGOOD: R13.1 R14.2 TP9.1 U1.2 | length 1525.3
  Top Layer w9: v3(1505,1300) 1508.27,1296.73 U1.2@1531.53,1296.73 ; v3(1746,1490) 1746.31,1489.69 R14.2@1746.31,1465 R13.1@1746.32,1430
  Signal Layer w9: v3(1505,1300) 1505,1325 1424.65,1405.35 1424.65,1449.65 1465,1490 v3(1746,1490) 2421.81,1490 2511.81,1400 v4(2625,1400)
SW: C1.2 L2.2 U1.5
  other v3: 1704,1039 1705,1064 1705,1091 1705,1118 1705,1144
SyncIn: R10.1 TP10.1 | length 1513.3
  Top Layer w9: v3(1426,1365) R10.1@1455.32,1365
  Signal Layer w9: v3(1426,1365) 1401,1365 1386,1380 1386,1493 1593,1700 v4(2625,1700)
VCC: C14.1 R8.1 R14.1 U1.7 | length 600.3
  Top Layer w10: v3(1450,1425) 1450,1405.32 R8.1@1455.32,1400 ; U1.7@1602.39,1296.73 1636.73,1296.73 C14.1@1640,1300 ; v3@1634.15,1338 1635,1337.15 C14.1@1635,1305 ; R14.1@1785.68,1465 v3(1814,1465)
  Signal Layer w10: v3(1450,1425) 1626,1425 1660,1391 ; v3(1634,1338) 1634,1365 1660,1391 ; v3(1814,1465) 1741.65,1465 1667.65,1391 1660,1391
Vin: C3.2 C8.1 L1.1 R1.2 R2.2 TP1.1 U1.4 | length 50.1
  Bottom Layer w9: R2.2@1420,1276 1420,1256 1430,1246 v3(1430,1230)
  other v1: 507.96,1445 560,1445 611.78,1445
  other v3: 1430,1145 1485,1170 1430,1190 1485,1210 1485,1250
VINX: C4.1 FB1.1 J1.1 TP2.1 | length 384
  Bottom Layer w50: TP2.1@175,2205 C4.1@559,2205
VINY: C2.1 C5.2 C6.1 C7.1 FB1.2 L1.2
VOUT: C10.2 C11.2 C12.2 C13.2 J2.1 L2.1 R6.2 R13.2 TP3.1 TP4.1 | length 719.3
  Top Layer w10: R13.2@1785.69,1430 1784.69,1429 R6.2@1784.69,1395 v3(1820,1395)
  Signal Layer w10: v3(1820,1395) 2097.38,1395 2250,1242.38 TP4.1@2250,1087
  other v3: 1559,938 1592,938 1531,955 1623,955 1531,980 1623,980
pads on no net: FID1.1 FID2.1 FID3.1 FID4.1 FID5.1 FID6.1 LBL1.0

## Polygon pours and split planes (outlines as drawn)
FB on Top Layer "TOP_LAYER_FB" (solid, remove dead copper, pour order 93): 1585,1313 1585,1334 1614,1334 1614,1313
MODE/SYNC on Top Layer "TOP_LAYER_MODE/SYNC" (solid, remove dead copper, pour order 91): 1549,1334 1549,1314 1520,1314 1520,1334
SW on Top Layer "TOP_LAYER_SW" (solid, remove dead copper, pour order 95): 1615,1257 1627,1245 1655,1245 1655,1232 1715,1172 1715,1028 1650,1028 1650,1175 1600,1225 1585,1225 1585,1262 1613,1262 1615,1260
VOUT on Top Layer "TOP_LAYER_Vout" (solid, remove dead copper, pour order 96): 1747,1000 1719,972 1644.23,972 1616.23,1000 1520,1000 1520,800 2893,800 2893,1265 1965,1265 1965,1000
Vin on Top Layer "Top Layer-Vin" (solid, remove dead copper, pour order 94): 1549,1145.03 1449.77,1144.77 1385,1080 1385,1035 1216,1035 1216,1260 1549,1260
GND on Top Layer "TOP_LAYER_GND" (solid, remove dead copper, pour order 98): 2947.57,58.89 47.57,58.89 47.57,2800 2947.57,2800
GND on Signal Layer "SIGNAL_LAYER_GND" (solid, remove dead copper, pour order 104): 2947.57,58.89 47.57,58.89 47.57,2800 2947.57,2800
Vin on Signal Layer "Signal Layer-Vin" (solid, remove dead copper, pour order 102): 1385,1080 1385,1035 1340,1035 764.99,1035.01 480,1320 480,1475 640,1475 640,1340 790,1190 1020,1190 1090,1260 1495,1260 1495,1162.5 1477.5,1145 1450,1145
GND on GND Layer "GND_LAYER_GND" (solid, remove dead copper, pour order 100): 2947.57,58.89 47.57,58.89 47.57,2800 2947.57,2800
VOUT on Bottom Layer "BOTTOM_LAYER_Vout" (solid, remove dead copper, pour order 108): 1527,1334 1586,1334 1586,1182 1604,1164 1604,998 1612,990 1628,990 1635,983 1635,950 1611,926 1539,926 1518,947 1518,998 1550,1030 1550,1142.69 1526.69,1166 1527,1166.31
SW on Bottom Layer "BOTTOM_LAYER_SW" (solid, remove dead copper, pour order 106): 1715,1157 1715,1035 1690,1010 1650,1010 1650,1157
GND on Bottom Layer "BOTTOM_LAYER_GND" (solid, remove dead copper, pour order 110): 2947.57,58.89 47.57,58.89 47.57,2800 2947.57,2800

## Keep-outs
Keep-Out Layer:
  text ".Layer_Name" at 577,-858.49 h60

## Other copper
Top Layer:
  region net NetC9_1: 930,1122 1049,1122 1097,1170 1152,1170 1152,1035 930,1035
  pour cut-out: 1685.29,1342 1675,1342 1675,1405 1684.81,1405
  pour cut-out: 1657.77,1285 1650,1285 1650,1342 1685.5,1342 1684.77,1310 1685.29,1243.15 1657.77,1243.15
  text ".Layer_Name" at 577,-858.49 h60
Bottom Layer:
  rectangle net VINY: 480,1580 645,2020
  rectangle net Vin: 478,1420 645,1549.27
  rectangle net VINX: 537,2100.5 586,2189.38
  region net VINX: 135,2130 95,2170 95,2245 125,2275 125,2460 175,2460 210,2495 210,2620 320,2730 505,2730 610,2625 610,2271.93 585,2246.93 585,2180 260,2180 210,2130
  region: 114,2180
  region net NetC2_2: 695,1835 695,1766 742,1766 760,1748 760,1685 815,1685 815,1919 760,1919 760,1848 747,1835
  text ".Layer_Name" at 577,-858.49 h60

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  lines w6: 1800,998 1900,998 ; 1800,1340 1900,1340 ; 1855,998 1855,1052 ; 1855,1275 1855,1340 ; 1520,998 1520,1340 1710,1340 1710,998 1520,998
  text "'.PRJ_Number'.PCB_Rev" at 1742,2377 h108.27
  text "8.7mm" at 1876,1065 h72.83 r90
  text "4.8mm" at 1518,879 h72.83
  text ".Layer_Name" at 577,-858.49 h60
Bottom Overlay:
  lines w6: 1520,998 1710,998 1710,1340 1520,1340 1520,998
  text ".Layer_Name" at 577,-858.49 h60
Top Paste:
  text ".Layer_Name" at 577,-858.49 h60
Bottom Paste:
  text ".Layer_Name" at 577,-858.49 h60
Top Solder:
  text ".Layer_Name" at 577,-858.49 h60
  text ".Layer_Name" at 577,-858.49 h60
Bottom Solder:
  text ".Layer_Name" at 577,-858.49 h60
Drill Guide:
  text ".Layer_Name" at 577,-858.49 h60
M1 Board Outline:
  lines w10: 2999,2501 3000,2500 ; 2999,2800 0,2800 0,0 3000,0 3000,2800
M2 Board Dimensions:
  rectangle: 125,-400 500,-275
  rectangle: 0,-275 125,-150
  lines w7: 0,-275 1000,-275 ; 125,-400 125,-150 ; 250,-400 250,-150 ; 500,-400 500,-150 ; 750,-400 750,-150 ; 0,-400 0,-150 1000,-150 1000,-400 0,-400
  text ".Layer_Name" at 577,-858.49 h60
M3 3D STEP Top:
  text ".Layer_Name" at 577,-858.49 h60
M4 3D STEP Bottom:
  text ".Layer_Name" at 577,-858.49 h60
M5 Assembly Top:
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4902,-1140 4902,-937.17
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 1153.5,-318.5 h60
  text "ASSEMBLY VARIANT:" at 1153,-434 h60
  text ".VariantName" at 2189,-434 h60
  text "PCB VIEWED FROM TOP SIDE" at -228.5,-655.67 h60
  text "BOARD #:" at 2248,-655.67 h60
  text ".PRJ_Number" at 2793.5,-655.67 h60
  text "REV:" at 3638,-655.67 h60
  text ".PCB_Rev" at 3929.5,-655.67 h60
  text "SVN REV:" at 4476,-655.67 h60
  text ".VersionControl_RevNumber" at 4982,-655.67 h60
  text "TID #:" at 2248,-859 h60
  text ".TID" at 2793.5,-859 h60
  text "PLOT NAME =" at -228.5,-1064.34 h60
  text ".plot_File_Name" at 577,-1064.34 h60
  text "GENERATED    :" at 2250,-1064.34 h60
  text ".Print_Date" at 3119.5,-1064.34 h60
  text ".Print_Time" at 3848.5,-1064.34 h60
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h60
M6 Assembly Bottom:
  lines w10: -292.5,-727.33 6309.5,-727.33 ; -290.5,-930.67 6309.5,-930.67 ; 1115.5,-1140.5 1115.5,-937.67 ; 1737.5,-727.33 1737.5,-524 ; 2577.5,-727.33 2577.5,-524 ; 3844.5,-1134 3844.5,-524 ; 4733.5,-1134 6309,-1134 6309,-524 -292.5,-524 -292.5,-1134 2304.5,-1134 6309.5,-1134 6309.5,-524
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 6102,-318 h60
  text ".VariantName" at 5058,-434 h60
  text "ASSEMBLY VARIANT:" at 6097,-434 h60
  text ".VersionControl_RevNumber" at 1035.5,-656.17 h60
  text "SVN REV:" at 1541.5,-656.17 h60
  text ".PCB_Rev" at 2088,-656.17 h60
  text "REV:" at 2379.5,-656.17 h60
  text ".PRJ_Number" at 3224,-656.17 h60
  text "BOARD #:" at 3769.5,-656.17 h60
  text "PCB VIEWED FROM BOTTOM SIDE" at 6246,-656.17 h60
  text ".TID" at 3224,-859.5 h60
  text "TID #:" at 3769.5,-859.5 h60
  text "TEXAS INSTRUMENTS" at 904.5,-1064.84 h60
  text ".Print_Time" at 2169,-1064.84 h60
  text ".Print_Date" at 2898,-1064.84 h60
  text "GENERATED    :" at 3767.5,-1064.84 h60
  text ".plot_File_Name" at 5440.5,-1064.84 h60
  text "PLOT NAME =" at 6246,-1064.84 h60
M9 Title Sheet:
  drawing of 57 lines, arcs and shapes, not listed
  text "1" at 739.84,8036.5 h70
  text "2" at 3235.5,8036.5 h70
  text "3" at 5724.84,8036.5 h70
  text "4" at 8231.51,8036.5 h70
  text "5" at 10730.5,8036.5 h70
  text "6" at 13235.5,8036.5 h70
  text "A" at -416.5,6893.5 h70
  text "A" at 14383.5,6893.5 h70
  text "B" at -416.5,4513.5 h70
  text "B" at 14383.5,4513.5 h70
  text "C" at -416.5,2138.5 h70
  text "C" at 14383.5,2138.5 h70
  text "PROJECT TITLE:" at 11343.5,277.5 h45
  text ".PRJ_Title" at 11393.5,144.17 h70
  text "DESIGNED FOR:" at 11343.5,-23.5 h45
  text ".PRJ_Customer" at 11393.5,-163.5 h70
  text "D" at -416.5,-231.5 h70
  text "D" at 14383.5,-231.5 h70
  text "FILE NAME:" at 11343.5,-323.5 h45
  text ".PCB_File_Name_No_Path" at 11393.5,-443.5 h70
  text "Texas Instruments (TI) and/or its licensors do not warrant the accuracy or completeness of this specification" at 6374,-605.34 h45
  text "ENGINEER:" at 11343.5,-613.5 h45
  text "LAYOUT BY:" at 12848.5,-613.5 h45
  text "or any information contained therein. TI and/or its licensors do not warrant that this design will meet" at 6329.01,-718 h45
  text ".PRJ_Engineer" at 11393.5,-768.49 h70
  text ".PCB_Layout" at 12899,-768.49 h70
  text "the specifications, will be suitable for your application or fit for any particular purpose, or will operate in" at 6329.01,-830.67 h45
  text ".Layer_Name" at 577,-858.49 h60
  text "ALTIUM DESIGNER VERSION:" at 12848.5,-923.5 h45
  text "an implementation. TI and/or its licensors do not warrant that the design is production worthy. You should" at 6329.01,-943.33 h45
  text "completely validate and test your design implementation to confirm the system functionality for your application." at 6374,-1056 h45
  text ".print_Scale" at 11393.5,-1056.83 h70
  text ".Application_BuildNumber" at 12899,-1056.83 h70
  text "1" at 739.84,-1263.5 h70
  text "2" at 3235.5,-1263.5 h70
  text "3" at 5724.84,-1263.5 h70
  text "4" at 8231.51,-1263.5 h70
  text "5" at 10730.5,-1263.5 h70
  text "6" at 13235.5,-1263.5 h70
M10 Fab Notes:
  drawing of 189 lines, arcs and shapes, not listed
  text "DESIGN INFORMATION" at 12382.02,6356.17 h60
  text "MIN. TRACK WIDTH:" at 11737.46,6224.05 h60
  text "6" at 12833.7,6224.05 h60
  text "MIL" at 12988.46,6224.05 h60
  text "MIN. CLEARANCE:" at 11737.46,6099.92 h60
  text "0.178" at 12697,6100 h60
  text "mm" at 12988.46,6099.92 h60
  text "MIN. VIA PAD SIZE:" at 11737.46,5975.8 h60
  text "20" at 12803.71,5975.8 h60
  text "MIL" at 12988.46,5975.8 h60
  text "0.127mm (5MIL)" at 12432.46,5845.9 h60
  text "MINIMUM ANNULAR RING" at 11408.23,5837.67 h60
  text "EXTERNAL" at 13140.46,5837.67 h60
  text "PER" at 11608.23,5727.55 h60
  text "IPC-D-275 CLASS 2 LEVEL C" at 11828.23,5727.54 h60
  text "MIL, HOLES" at 13316.46,5627.07 h60
  text "+/-" at 12924,5618.48 h60
  text "+/-" at 13778,5618.48 h60
  text "REGISTRATION TOLERANCES:" at 11408.23,5617.42 h60
  text "METAL" at 12608,5617.42 h60
  text "5" at 13184.2,5617.42 h60
  text "3" at 14017.2,5617.42 h60
  text "MIL" at 14133.46,5617.42 h60
  text "HOLE SIZE TOLERANCE (UNLESS OTHERWISE SPECIFIED):" at 11408.23,5519.1 h60
  text "+/-" at 13778,5516.23 h60
  text "3" at 14017.2,5515.17 h60
  text "MIL" at 14133.46,5515.17 h60
  text "MATERIAL:" at 11333.46,5377.52 h60
  text "FR-4 High Tg" at 12319.9,5249 h60
  text "X" at 11620,5245 h60
  text "FR-408" at 11754.46,5236.49 h60
  text "OTHER" at 13242.46,5236.49 h60
  text "60 MIL (1.6mm) +/-10%" at 12074.56,5093.46 h60
  text "X" at 11954.46,5091.01 h60
  text "THICKNESS:" at 11408.23,5085.24 h60
  text "OTHER" at 13359.46,5085.24 h60
  text "TOLERANCE:" at 11408.23,4946.92 h60
  text "X" at 12256.46,4946.92 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4946.92 h60
  text "OTHER +/-" at 12434.46,4802.73 h60
  text "BOW & TWIST:" at 11408.23,4657.54 h60
  text "X" at 12256.46,4657.54 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4657.54 h60
  text "OTHER +/-" at 12434.46,4510.85 h60
  text "DRILLING:" at 11333.46,4380.23 h60
  text "NC_DRILL FILES" at 13094.46,4275.04 h60
  text "REFERENCE:" at 11408.23,4271.1 h60
  text "X" at 12065.46,4271.01 h60
  text "AS SHOWN" at 12243.46,4271.1 h60
  text "X" at 12966.46,4271.1 h60
  text "OTHER" at 13392.46,4128.85 h60
  text "PTH COPPER THICKNESS:" at 11407.91,4125.32 h60
  text "X" at 12547.14,4125.32 h60
  text "20-30 um" at 12675.14,4125.32 h60
  text "BOARD FINISH:" at 11333.46,3977.73 h60
  text "SILKSCREEN:" at 11488.68,3867.6 h60
  text "X" at 12446.46,3867.6 h60
  text "TOP" at 12563.46,3867.6 h60
  text "X" at 12956.46,3867.6 h60
  text "BOTTOM" at 13074.46,3867.6 h60
  text "SILKSCREEN COLOR:" at 11488.68,3712.41 h60
  text "X" at 12445.46,3712.41 h60
  text "WHITE" at 12563.46,3712.41 h60
  text "OTHER" at 13074.46,3712.41 h60
  text "X" at 12576.46,3568.96 h60
  text "GREEN" at 12694.46,3568.96 h60
  text "OTHER" at 13312.46,3568.96 h60
  text "SOLDER RESIST COLOR:" at 11488.68,3562.1 h60
  text "X" at 12576.46,3414.71 h60
  text "MATTE" at 12694.46,3414.71 h60
  text "SEMI-GLOSS" at 13312,3414.07 h60
  text "IMMERSION GOLD (ENIG)" at 12394.46,3241.94 h60
  text "ENEPIG" at 13732,3234.72 h60
  text "SURFACE FINISH:" at 11333.46,3233.72 h60
  text "X" at 12216.46,3233.72 h60
  text "IMM. TIN/SILVER OR EQUIV" at 11663,3096.4 h60
  text "OTHER" at 13094.46,3092.47 h60
  text "X" at 12215,2940 h60
  text "ARRAY/PANEL:" at 11333.46,2937.09 h60
  text "CUT AND TRIM PER M1 BOARD OUTLINE" at 12394.46,2928.87 h60
  text "N.C. ROUTE" at 12394.46,2792.9 h60
  text "V. SCORE" at 13260.46,2792.9 h60
  text "CERTIFICATION:" at 11333.46,2663.77 h60
  text "MATERIALS AND WORKMANSHIP FOR ALL PCBS" at 12058.46,2663.77 h60
  text "TO MEET OR EXCEED THE REQUIREMENTS OF:" at 12058.46,2569.71 h60
  text "X" at 11695.97,2441.08 h60
  text "ANSI IPC-A-600F CLASS ->" at 11823.96,2441.08 h60
  text "X" at 13471.97,2441.08 h60
  text "2" at 13581.96,2441.08 h60
  text "1" at 13266.96,2439.58 h60
  text "3" at 13935.96,2439.58 h60
  text "X" at 12507.97,2293.39 h60
  text "RoHS" at 12635.96,2293.39 h60
  text "OTHER" at 13280.36,2293.39 h60
  text "PER ORDER" at 13677.42,2293.39 h60
  text "ALL BOARDS MUST MEET OR EXCEED UL94-V0 REQUIREMENTS." at 11361,2139.57 h60
  text "PCB MUST BEAR THE UL94V-0 UL REGISTERED MATERIAL ID NUMBER" at 11361,2023.5 h60
  text "ADDITIONAL REQUIREMENTS:" at 11333.46,1854.08 h60
  text "MICROSECTION:" at 11408.23,1746.95 h60
  text "YES" at 12313.96,1746.95 h60
  text "REQUIRED" at 13175.46,1602.62 h60
  text "BARE BOARD ELEC. TEST:" at 11408.23,1599.76 h60
  text "NONE" at 12713.96,1599.76 h60
  text "X" at 13057.46,1599.76 h60
  text "PER ORDER" at 13767.46,1599.76 h60
  text "XX MIL VIAS REQUIRE NON-CONDUCTIVE FILL AND PLANARIZE" at 11576.38,1394.82 h59
  text "XX MIL VIAS REQUIRE CONDUCTIVE FILL AND PLANARIZE" at 11584.38,1290.84 h60
  text "OUTER XX MIL VIAS REQUIRE 50 OHM SINGLE-ENDED IMPEDANCE" at 11583.39,1127.46 h58
  text "LAYER 2 & 3 (INNER LAYERS) XX MIL WIDE, XX MIL SPACE / TRACES REQUIRE 100 OHM DIFFERENTIAL IMPEDANCE" at 11575.39,891.74 h60
  text ".Layer_Name" at 577,-858.49 h60
M11 Gerber Information:
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4902,-1140 4902,-937.17
  text "ALL ARTWORK VIEWED FROM TOP SIDE" at -228.5,-655.67 h60
  text "BOARD #:" at 2248,-655.67 h60
  text ".PRJ_Number" at 2793.5,-655.67 h60
  text "REV:" at 3638,-655.67 h60
  text ".PCB_Rev" at 3929.5,-655.67 h60
  text "SVN REV:" at 4476,-655.67 h60
  text ".VersionControl_RevNumber" at 4982,-655.67 h60
  text "LAYER NAME =" at -228.5,-858.49 h60
  text "TID #:" at 2248,-859 h60
  text ".TID" at 2793.5,-859 h60
  text "PLOT NAME =" at -228.5,-1064.34 h60
  text ".plot_File_Name" at 577,-1064.34 h60
  text "GENERATED    :" at 2250,-1064.34 h60
  text ".Print_Date" at 3119.5,-1064.34 h60
  text ".Print_Time" at 3848.5,-1064.34 h60
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h60
M12 Stackup:
  drawing of 295 lines, arcs and shapes, not listed
  text "Layer" at 3780.58,7030 h60
  text "Name" at 4190.49,7030 h60
  text "Material" at 5120.23,7030 h60
  text "Thickness" at 5980,7030 h60
  text "Constant" at 6629.84,7030 h60
  text "Board Layer Stack" at 7199.7,7030 h60
  text "1" at 3780.58,6910 h60
  text "Top Overlay" at 4190.49,6910 h60
  text "2" at 3780.58,6790 h60
  text "Top Solder" at 4190.49,6790 h60
  text "Solder Resist" at 5120.23,6790 h60
  text "0.40mil" at 5980,6790 h60
  text "3.5" at 6629.84,6790 h60
  text "3" at 3780.58,6670 h60
  text "Top Layer" at 4190.49,6670 h60
  text "Copper" at 5120.23,6670 h60
  text "1.40mil" at 5980,6670 h60
  text "4" at 3780.58,6550 h60
  text "Dielectric1" at 4190.49,6550 h60
  text "FR-4 High Tg" at 5120.23,6550 h60
  text "12.50mil" at 5980,6550 h60
  text "4.2" at 6629.84,6550 h60
  text "5" at 3780.58,6430 h60
  text "GND Layer" at 4190.49,6430 h60
  text "Copper" at 5120.23,6430 h60
  text "0.70mil" at 5980,6430 h60
  text "6" at 3780.58,6310 h60
  text "Dielectric 2" at 4190.49,6310 h60
  text "FR-4 High Tg" at 5120.23,6310 h60
  text "32.00mil" at 5980,6310 h60
  text "4.2" at 6629.84,6310 h60
  text "7" at 3780.58,6190 h60
  text "Signal Layer" at 4190.49,6190 h60
  text "Copper" at 5120.23,6190 h60
  text "0.70mil" at 5980,6190 h60
  text "8" at 3780.58,6070 h60
  text "Dielectric 3" at 4190.49,6070 h60
  text "FR-4 High Tg" at 5120.23,6070 h60
  text "12.50mil" at 5980,6070 h60
  text "4.2" at 6629.84,6070 h60
  text "9" at 3780.58,5950 h60
  text "Bottom Layer" at 4190.49,5950 h60
  text "Copper" at 5120.23,5950 h60
  text "1.40mil" at 5980,5950 h60
  text "10" at 3780.58,5830 h60
  text "Bottom Solder" at 4190.49,5830 h60
  text "Solder Resist" at 5120.23,5830 h60
  text "0.40mil" at 5980,5830 h60
  text "3.5" at 6629.84,5830 h60
  text "11" at 3780.58,5710 h60
  text "Bottom Overlay" at 4190.49,5710 h60
  text ".Layer_Name" at 577,-858.49 h60
M13 Component Bodies Top:
  text ".Layer_Name" at 577,-858.49 h60
M14 Component Bodies Bottom:
  text ".Layer_Name" at 577,-858.49 h60
M15 Courtyards Top:
  text ".Layer_Name" at 577,-858.49 h60
M16 Courtyards Bottom:
  text ".Layer_Name" at 577,-858.49 h60
Drill Drawing:
  lines w10: 3836.09,991.7 3891.34,991.7 3891.34,1046.95 3836.09,1046.95 3836.09,991.7 ; 3836.09,1129.83 3849.9,1129.83 3863.72,1116.02 3877.53,1129.83 3891.34,1129.83 3877.53,1143.64 3891.34,1157.46 3877.53,1157.46 3863.72,1171.27 3849.9,1157.46 3836.09,1157.46 3849.9,1143.64 3836.09,1129.83 ; 3836.09,1240.34 3863.72,1254.15 3891.34,1240.34 3877.53,1267.96 3891.34,1295.59 3863.72,1281.78 3836.09,1295.59 3849.9,1267.96 3836.09,1240.34 ; 3836.09,1419.91 3891.34,1419.91 3863.72,1364.66 3836.09,1419.91
  lines w12: 3786,954.4 7017.49,954.4 ; 3786,1451.68 7017.49,1451.68 ; 4123.86,830.08 4123.86,1576 ; 4455.86,830.08 4455.86,1576 ; 5092.43,830.08 5092.43,1576 ; 5351.57,830.08 5351.57,1576 ; 5726.72,830.08 5726.72,1576 ; 6451.05,830.08 6451.05,1576 ; 3786,830.08 7017.49,830.08 7017.49,1576 3786,1576 3786,830.08
  text "Symbol" at 3860.59,1488.98 h72
  text "Quantity" at 4161.16,1488.98 h72
  text "Finished Hole Size" at 4493.16,1488.98 h72
  text "Plated" at 5129.72,1488.98 h72
  text "Hole Type" at 5388.86,1488.98 h72
  text "Drill Layer Pair" at 5764.02,1488.98 h72
  text "Hole Tolerance" at 6488.35,1488.98 h72
  text "242" at 4161.16,1364.66 h60
  text "10.00mil (0.254mm)" at 4493.16,1364.66 h60
  text "PTH" at 5129.72,1364.66 h60
  text "Round" at 5388.86,1364.66 h60
  text "Top Layer - Bottom Layer" at 5764.02,1364.66 h60
  text "4" at 4161.16,1240.34 h60
  text "98.43mil (2.500mm)" at 4493.16,1240.34 h60
  text "PTH" at 5129.72,1240.34 h60
  text "Round" at 5388.86,1240.34 h60
  text "Top Layer - Bottom Layer" at 5764.02,1240.34 h60
  text "4" at 4161.16,1116.02 h60
  text "126.00mil (3.200mm)" at 4493.16,1116.02 h60
  text "PTH" at 5129.72,1116.02 h60
  text "Round" at 5388.86,1116.02 h60
  text "Top Layer - Bottom Layer" at 5764.02,1116.02 h60
  text "4" at 4161.16,991.7 h60
  text "214.57mil (5.450mm)" at 4493.16,991.7 h60
  text "PTH" at 5129.72,991.7 h60
  text "Round" at 5388.86,991.7 h60
  text "Top Layer - Bottom Layer" at 5764.02,991.7 h60
  text "254 Total" at 4161.16,867.38 h60
  text ".Layer_Name" at 577,-858.49 h60
M17 Embedded Cavity:
  text ".Layer_Name" at 577,-858.49 h60
M18 Embedded Assembly:
  text ".Layer_Name" at 577,-858.49 h60
M19 Embedded Keepout:
  text ".Layer_Name" at 577,-858.49 h60

## Dimensions
0,0 to 3000,0 on M2 Board Dimensions
0,0 to 0,2800 on M2 Board Dimensions
0,-400 to 1000,-400 on M2 Board Dimensions